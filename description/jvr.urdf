Commit message: base_link and chassis correct

File: description/jvr.urdf (robot description, URDF)
Before this commit: robot jvr, 2 links, 1 joints
Joints:
- joint chassis_joint: origin xyz=-0.035 0 0 -> xyz=-0.14 0 -0.015
